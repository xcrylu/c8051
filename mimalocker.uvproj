# Keil uVision project mimalocker.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51RC2 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF)  XRAM (0-0x3FF) CLOCK(40000000) MODP2
  output: mimalocker +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\driver
  group app
    ./: mimasuo.c STARTUP.A51
  group driver
    ./driver/: 24c02.c com.c i2c.c key.c lcd1602.c serial.c ds18b20.c
